# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CORE;..\SYSTEM\BSP;..\SYSTEM\BSP\Bsp_Inc;..\SYSTEM\BSP\Bsp_Src;..\USER\inc;..\USER\src;..\UTILITIES\CanFestival-3\include;..\UTILITIES\CanFestival-3\include\STM32;..\UTILITIES\CanFestival-3\objdict;..\UTILITIES\FreeRTOSv8.0.1\include;..\UTILITIES\FreeRTOSv8.0.1\portable\RVDS\ARM_CM3;..\UTILITIES\STM32F10x_StdPeriph_Driver\inc;..\UTILITIES\STM32F10x_StdPeriph_Driver\scr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/src/: main.c functions.c stm32f10x_it.c serial_debug.c
  group BSP
    ../SYSTEM/BSP/: bsp.c
    ../SYSTEM/BSP/Bsp_Src/: bsp_led.c
  group Robot_Control
    ../USER/src/: canopen_thread.c
  group CMSIS
    ../USER/src/: system_stm32f10x.c
  group MDK-ARM
    ../CORE/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../UTILITIES/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../UTILITIES/FreeRTOSv8.0.1/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../UTILITIES/FreeRTOSv8.0.1/portable/MemMang/: heap_2.c
    ../UTILITIES/FreeRTOSv8.0.1/portable/RVDS/ARM_CM3/: port.c
  group CANOpen
    ../UTILITIES/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../UTILITIES/CanFestival-3/drivers/STM32/: can_STM32.c timer_STM32.c
  group Objdict
    ../UTILITIES/CanFestival-3/objdict/: ObjDict_CAN1.c ObjDict_CAN2.c LIFTER_OD.c
  group Doc
    ../: Readme.md
