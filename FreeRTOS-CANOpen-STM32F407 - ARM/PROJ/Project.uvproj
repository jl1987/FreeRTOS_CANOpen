# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\CORE;..\SYSTEM\BSP;..\SYSTEM\BSP\Bsp_Inc;..\USER\inc;..\USER\src;..\HARDWARE\LED;..\HARDWARE\ultrasonic_sensor;..\UTILITIES\STM32F40x_FWLib\inc;..\UTILITIES\STM32F40x_FWLib\src;..\UTILITIES\CanFestival-3\include;..\UTILITIES\CanFestival-3\include\STM32;..\UTILITIES\CanFestival-3\objdict;..\UTILITIES\FreeRTOSv8.0.1\include;..\UTILITIES\FreeRTOSv8.0.1\portable\RVDS\ARM_CM4F;..\HARDWARE;..\HARDWARE\motor;..\HARDWARE\pneumatic;..\HARDWARE\touch_sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/src/: main.c functions.c stm32f4xx_it.c serial_debug.c
  group BSP
    ../SYSTEM/BSP/Bsp_Src/: bsp_led.c
  group Robot_Control
    ../USER/src/: canopen_thread.c arm_control.c sensor.c
  group Hardware
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/pneumatic/: pneumatic.c
    ../HARDWARE/touch_sensor/: touch_sensor.c
  group CMSIS
    ../USER/src/: system_stm32f4xx.c
  group MDK-ARM
    ../CORE/: startup_stm32f4xx.s
  group FwLib
    ../UTILITIES/STM32F40x_FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../UTILITIES/FreeRTOSv8.0.1/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../UTILITIES/FreeRTOSv8.0.1/portable/MemMang/: heap_2.c
    ../UTILITIES/FreeRTOSv8.0.1/portable/RVDS/ARM_CM4F/: port.c
  group CANOpen
    ../UTILITIES/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../UTILITIES/CanFestival-3/drivers/STM32/: can_STM32.c timer_STM32.c
  group Objdict
    ../UTILITIES/CanFestival-3/objdict/: ARM_OD.c
  group Doc
    ../: Readme.md
